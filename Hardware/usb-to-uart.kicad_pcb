# Repository abhishek-xi/cp2102-usb-c-uart-converter

File README.md:

# CP2102 USB Type-C to UART Converter

A compact USB Type-C to UART converter based on the Silicon Labs **CP2102** USB-to-UART bridge IC. This board provides a reliable serial communication interface for programming, debugging, and data exchange with embedded systems.

## Features

- USB Type-C interface
- CP2102 USB-to-UART bridge
- TX and RX activity LEDs
- External UART header
- USB-powered operation
- Compact PCB design
- Designed using KiCad

## Hardware Specifications

| Parameter | Value |
|-----------|-------|
| USB Interface | USB Type-C |
| USB-to-UART IC | CP2102 |
| Supply Voltage | 5V (USB VBUS) |
| UART Signals | TX, RX, GND |
| Status LEDs | TX Activity, RX Activity |
| Design Tool | KiCad 9 |

## Overview

This project implements a USB Type-C to UART converter using the CP2102 USB-to-Serial bridge IC. The board allows communication between a computer and microcontroller-based systems through a standard UART interface.

The design includes:
- USB Type-C connector for power and data
- CP2102 USB-UART controller
- TX/RX status indication LEDs
- External UART header for easy interfacing
- Decoupling capacitors for stable operation

## Pinout

| Pin | Function |
|------|----------|
| TX | UART Transmit |
| RX | UART Receive |
| RST | Reset |
| VBUS | USB 5V Output |
| GND | Ground |

## Applications

- Microcontroller programming
- Embedded system debugging
- UART communication testing
- Serial data logging
- IoT device development
- Bootloader flashing

## Getting Started

1. Connect the board to a computer using a USB Type-C cable.
2. Install CP2102 drivers if required by your operating system.
3. Connect TX, RX, and GND to the target device.
4. Open a serial terminal application.
5. Select the detected COM port and start communication.

## Software Compatibility

- Windows
- Linux
- macOS

## Future Improvements

- USB ESD protection
- RTS/CTS hardware flow control
- Auto-reset circuitry for development boards
- Additional status indicators
- Enhanced protection circuitry

## Author

**Abhishek B Kumbar**  
Electronics and Communication Engineering (ECE)

## License

This project is licensed under the MIT License.

## KiCad design Hardware/usb-to-uart.kicad_pcb

Parts:
C1, C2, C3, C4: 100nF; C_0201_0603Metric
D1, D2: LED; LED_0201_0603Metric
D3, D4, D5: LESD5D5.0CT1G; TVS_LESD5D5.0CT1G; PARTREV O
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J2: Conn_01x05_Pin; PinHeader_1x05_P2.54mm_Horizontal
R1, R2: 5.1k; R_0201_0603Metric
R3: 10k; R_0201_0603Metric
R4, R5, R6, R7: 1k; R_0201_0603Metric
U1: CP2102N-Axx-xQFN28; QFN-28-1EP_5x5mm_P0.5mm_EP3.35x3.35mm

Connections:
/D+: D3.2, J1.A6 (D+), J1.B6 (D+), U1.4 (D+)
/D-: D4.2, J1.A7 (D-), J1.B7 (D-), U1.5 (D-)
/RST: C2.2, J2.5
/RX: J2.3, R5.1
/TX: J2.4, R4.1
/VBUS: C3.1, C4.1, D5.2, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J2.2, R3.1, R6.1, R7.1, U1.7 (VREGIN), U1.8 (VBUS)
GND: C1.1, C3.2, C4.2, D3.1, D4.1, D5.1, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.1, R1.2, R2.2, U1.3 (GND), U1.29 (GND)
unnamed: D1.2 (A), R6.2
unnamed: D1.1 (K), R4.2, U1.26 (TXD)
unnamed: D2.2 (A), R7.2
unnamed: D2.1 (K), R5.2, U1.25 (RXD)
unnamed: J1.A5 (CC1), R1.1
unnamed: J1.B5 (CC2), R2.1
unnamed: C1.2, U1.6 (VDD)
unnamed: C2.1, U1.28 (~DTR)
unnamed: R3.2, U1.9 (~RST)

Notes on the sheet:
USB TYPE C
CP2102
EXTERNAL PINS

Board: 2 copper layers, 36.0 x 17.0 mm, 19 parts (0 on the bottom side), 16 nets.
